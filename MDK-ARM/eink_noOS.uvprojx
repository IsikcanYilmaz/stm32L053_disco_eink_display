# Keil uVision project eink_noOS.uvprojx, settings and files
target eink_noOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L053C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: eink_noOS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32L0xx_HAL_Driver/Inc;    ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;    ../Drivers/CMSIS/Include;    ..\Drivers\BSP\STM32L0538-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rcc.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_uart.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash.c stm32l0xx_hal_cortex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c
  group Application/User
    ../Src/: gpio.c usart.c stm32l0xx_it.c i2c.c main.c tim.c stm32l0xx_hal_msp.c spi.c dma.c
  group EPD_Driver
    ../Drivers/BSP/STM32L0538-Discovery/: stm32l0538_discovery.c stm32l0538_discovery_epd.c
    ../Drivers/BSP/Components/gde021a1/: gde021a1.c
